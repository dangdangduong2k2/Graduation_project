<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Main_Robot.ewp</path>
  </project>
  <batchBuild />
</workspace>
